# Keil uVision project iox_f0020.uvprojx, settings and files
target IOX_F0020 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0020B1T MindMotion
  pack: MindMotion.MM32F0020_DFP.0.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: iox_f0020 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  __CC_ARM
  c include: ..\src;..\..\LIB_Files\MM32F0020\Include;..\..\LIB_Files\MM32F0020\HAL_Lib\Inc;..\..\LIB_Files\MM32F0020\CMSIS\KEIL_Core;..\..\SYSTEM\UART;..\..\SYSTEM\WDG;..\..\SYSTEM\DELAY;..\..\HARDWARE\LED;..\..\HARDWARE\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group STARTUP
    ../../LIB_Files/MM32F0020/Source/: system_mm32f0020.c
    ../../LIB_Files/MM32F0020/Source/KEIL_StartAsm/: startup_mm32f0020_keil.s
  group IOX
    ../src/: main.c iox_sys.c env_ku.c iox_pins.c iox_scan.c iox_evt.c iox_adc.c iox_lwdt.c iox_proto.c iox_config.h
  group SYSTEM
    ../../SYSTEM/UART/: uart.c
    ../../SYSTEM/WDG/: wdg.c
    ../../HARDWARE/GPIO/: gpios.c
  group HAL_Lib
    ../../LIB_Files/MM32F0020/HAL_Lib/Src/: hal_rcc.c hal_gpio.c hal_uart.c hal_adc.c hal_iwdg.c hal_misc.c
